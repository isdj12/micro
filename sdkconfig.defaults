## sdkconfig.defaults
```kconfig
# Enable custom bootloader hooks
CONFIG_BOOTLOADER_CUSTOM_RESERVE_RTC=n

# This file ensures bootloader hooks are enabled
```
